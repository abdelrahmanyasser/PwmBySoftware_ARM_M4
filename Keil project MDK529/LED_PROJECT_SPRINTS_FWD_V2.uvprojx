# Keil uVision project LED_PROJECT_SPRINTS_FWD_V2.uvprojx, settings and files
target Tiva c (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED_PROJECT_SPRINTS_FWD_V2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\MCAL\Inc;..\MCAL\Config
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./: system_TM4C123.c startup_TM4C123.s
  group Mcal
    ../MCAL/: Dio.c Gpt.c IntCtrl.c Port.c
  group Config
    ../MCAL/Config/: Gpt_Lcfg.c IntCtrl_Lcfg.c Port_Lcfg.c
  group App
    ../APPLICATION/: Debugapp.c mainApp.c
